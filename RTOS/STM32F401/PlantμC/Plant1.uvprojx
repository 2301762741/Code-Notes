# Keil uVision project Plant1.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Plant1
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: .\APP;.\Ports;.\Source;.\User
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source
    ./Source/: os.h os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c os_trace.h ucos_ii.h
  group User
    ./User/: main.c stm32f4xx_it.c stm32f4xx_it.h System.h Delay.c Delay.h
  group Ports
    ./Ports/: os_cpu_a.asm os_cpu_c.c os_cpu.h
  group APP
    ./APP/: os_cfg.h app_hooks.c app_cfg.h
  group Hardware
    ./Hardware/: LED.c
software components: CMSIS:CORE 5.0.1, Device:Startup 2.6.3
